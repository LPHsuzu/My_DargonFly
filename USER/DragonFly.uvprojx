# Keil uVision project DragonFly.uvprojx, settings and files
target DragonFly (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F411CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DragonFly
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F411xE,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\DRIVER\inc;..\FWLIB\inc;..\USER;..\COMMUNICATE;..\CONTROL;..\IMU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ../CMSIS/: startup_stm32f411xe.s system_stm32f4xx.c
  group USER
    ./: main.c stm32f4xx_it.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group DRIVER
    ../DRIVER/src/: led.c usart.c iic_analog.c delay.c exit.c mpu6500.c spi.c si24r1.c nvicconfig.c fbm320.c timer.c flash.c power.c motor.c spl06.c
  group IMU
    ../IMU/: structconfig.h filter.c imu.c
  group CONTROL
    ../CONTROL/: control.c paramsave.c pid.c altitude.c
  group COMMUNICATE
    ../COMMUNICATE/: remotedata.c ANO_DT.c
